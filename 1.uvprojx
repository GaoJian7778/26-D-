# Keil uVision project 1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWLIB\inc;.\USER;D:\keil\ARM\ARMCC\include;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\port;.\FreeRTOS\src;.\HARDWARE\BLE;.\HARDWARE\LCD;.\FreeRTOS\port\RVDS\ARM_CM4F;.\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c Key.c Key.h tasks.c ui.c
  group FREERTOS
    ./FreeRTOS/src/: event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/port/RVDS/ARM_CM4F/: port.c portmacro.h
    ./FreeRTOS/port/MemMang/: heap_4.c
  group HARDWARE
    ./HARDWARE/BLE/: ble.c ble.h protocol.c protocol.h
    ./HARDWARE/LCD/: FONT.H gui.c gui.h lcd.c lcd.h
    ./HARDWARE/FLASH/: flash_store.c flash_store.h
